FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = "file://0001-triplet-strings-with-only-two-parts-in-moz-configure.patch"
